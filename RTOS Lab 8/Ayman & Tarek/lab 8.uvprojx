# Keil uVision project lab 8.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab 8
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6LangP=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: bitwise_operation.h DIO.c DIO.h tm4c123gh6pm.h types.h main.c
    ../../../../../../Senior 1/Embedded/Labs/Lab7/Lab7_GPIO_Interrupts/Task 2/: interrupt.c interrupt.h
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Heap 10.5.1, CMSIS:CORE 5.6.0, Device:Startup 1.0.1
